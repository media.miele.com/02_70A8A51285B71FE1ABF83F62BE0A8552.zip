Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 9008600b-8ef9-4c6f-8c3c-fc6e9951a633, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T21:46:00+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07077460_D_KM6002:26600252_D_7077460_KM6002, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 574 mm; Height: 40 mm; Depth: 514 mm
Classification: E1090320 Uniformat (Uniformat); Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Cast, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26600252_D_7077460_KM6002; sets with these values: 2
